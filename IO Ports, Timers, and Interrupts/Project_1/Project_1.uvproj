# Keil uVision project Project_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS89C450 Dallas Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFFF) CLOCK(33000000) MODDP2
  output: Project_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Project_1.c
